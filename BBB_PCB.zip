# Allegro board BeagleBone_Black_RevB5_NO_LOGO.brd (continued)
## Nets (continued)
HDMI_TX2-: D7.1 P6.5(DAT2-) U11.44(TX2-)
HDMI_TXC+: D6.4 P6.12(CLK+) U11.38(TXC+)
HDMI_TXC-: D6.5 P6.14(CLK-) U11.37(TXC-)
HDMICLK_DISN: U5.V17(GPMC_A11/GMII2_RXD0/RGMII2_RD0/) Y4.1(OE)
I2C0_SCL: R3.2 U2.28(SCL) U5.C16(I2C0_SCL/TIMER7/UART2_RTSN/ECAP) U7.1(SCL) U11.52(CSCL)
I2C0_SDA: R4.2 U2.27(SDA) U5.C17(I2C0_SDA/TIMER4/UART2_CTSN/ECAP) U7.3(SDA) U11.51(CSDA)
I2C1_SCL: P9.17(9) U5.A16(SPI0_CS0/MMC2_SDWP/I2C1_SCL/EHR)
I2C1_SDA: P9.18(34) U5.B16(SPI0_D1/MMC1_SDWP/I2C1_SDA/EHRP)
I2C2_SCL: P9.19(10) U5.D17(UART1_RTSN/TIMER5/DCAN0_RX/I2C2)
I2C2_SDA: P9.20(35) U5.D18(UART1_CTSN/TIMER6/DCAN0_TX/I2C2)
JTAG_EMU0: P2.13(EMU0) R23.2 U5.C14(EMU0/GPIO3_7)
JTAG_EMU1: P2.14(EMU1) R24.2 U5.B14(EMU1/GPIO3_8)
JTAG_TCK: P2.9(TCKRTN) P2.11(TCK) U5.A12(TCK)
JTAG_TDI: P2.3(TDI) U5.B11(TDI)
JTAG_TDO: P2.7(TDO) U5.A11(TDO)
JTAG_TMS: P2.1(TMS) U5.C11(TMS)
JTAG_TRSTN: P2.2(TRSTN) R25.1 U5.B10(NTRST)
LCD_DATA0: C173.1 P8.45(23) R70.2 R95.1 U5.R1(LCD_DATA0/GPMC_A0//EHRPWM2A//PR) U11.15(VPC3)
LCD_DATA1: C171.1 P8.46(48) R69.2 R94.1 U5.R2(LCD_DATA1/GPMC_A1//EHRPWM2B//PR) U11.13(VPC4)
LCD_DATA2: C172.1 P8.43(22) R68.2 R75.1 R93.1 U5.R3(LCD_DATA2/GPMC_A2//EHRPWM2_TRIP) U11.12(VPC5)
LCD_DATA3: C170.1 P8.44(47) R67.2 R92.1 U5.R4(LCD_DATA3/GPMC_A3//EHRPWM2_SYNC) U11.11(VPC6)
LCD_DATA4: C169.1 P8.41(21) R66.2 R91.1 U5.T1(LCD_DATA4/GPMC_A4//EQEP2A_IN//P) U11.10(VPC7)
LCD_DATA5: C163.1 P8.42(46) R65.2 R90.1 U5.T2(LCD_DATA5/GPMC_A5//EQEP2B_IN//P) U11.7(VPB2)
LCD_DATA6: C162.1 P8.39(20) R64.2 R89.1 U5.T3(LCD_DATA6/GPMC_A6/PR1_EDIO_DATA) U11.6(VPB3)
LCD_DATA7: C161.1 P8.40(45) R63.2 R88.1 U5.T4(LCD_DATA7/GPMC_A7/PR1_EDIO_DATA) U11.3(VPB4)
LCD_DATA8: C160.1 P8.37(19) R62.2 R87.1 U5.U1(LCD_DATA8/GPMC_A12/EHRPWM1_TRIP) U11.2(VPB5)
LCD_DATA9: C157.1 P8.38(44) R61.2 R86.1 U5.U2(LCD_DATA9/GPMC_A13/EHRPWM1_SYNC) U11.1(VPB6)
LCD_DATA10: C156.1 P8.36(43) R60.2 R85.1 U5.U3(LCD_DATA10/GPMC_A14/EHRPWM1A/MC) U11.64(VPB7)
LCD_DATA11: C168.1 P8.34(42) R59.2 R84.1 U5.U4(LCD_DATA11/GPMC_A15/EHRPWM1B/MC) U11.60(VPA3)
LCD_DATA12: C167.1 P8.35(18) R58.2 R83.1 U5.V2(LCD_DATA12/GPMC_A16/EQEP1A_IN/M) U11.59(VPA4)
LCD_DATA13: C166.1 P8.33(17) R57.2 R82.1 U5.V3(LCD_DATA13/GPMC_A17/EQEP1B_IN/M) U11.58(VPA5)
LCD_DATA14: C165.1 P8.31(16) R56.2 R81.1 U5.V4(LCD_DATA14/GPMC_A18/EQEP1_INDEX) U11.57(VPA6)
LCD_DATA15: C164.1 P8.32(41) R55.2 R80.1 U5.T5(LCD_DATA15/GPMC_A19/EQEP1_STROB) U11.56(VPA7)
LCD_DE: P8.30(40) R48.2 U11.20(DE/VREF)
LCD_HSYNC: P8.29(15) R47.2 U11.22(HSYNC/VREF)
LCD_PCLK: P8.28(39) R45.2 U11.4(PCLK)
LCD_VSYNC: P8.27(14) R46.2 U11.21(VSYNC/VREF)
LCDDE: R48.1 U5.R6(LCD_AC_BIAS_EN/GPMC_A11//PR1_ED)
LCDPCLK: R45.1 U5.V5(LCD_PCLK/GPMC_A10//PR1_EDIO_DAT)
LCDVHYNC: R47.1 U5.R5(LCD_HSYNC/GPMC_A9//PR1_EDIO_DAT)
LCDVSYNC: R46.1 U5.U5(LCD_VSYNC/GPMC_A8//PR1_EDIO_DAT)
LDO_PGOOD: U2.46(LDO_PGOOD) U5.B5(RTC_PORZN)
LEDAA: D2.2(A) R72.2
LEDAC: D2.1(C) Q1.6(3)
LEDBA: D3.2(A) R73.2
LEDBC: D3.1(C) Q1.3
LEDCA: D4.2(A) R74.2
LEDCC: D4.1(C) Q2.6(3)
LEDDA: D5.2(A) R71.2
LEDDC: D5.1(C) Q2.3
MDIO_CLK: U5.M18(MDIO_CLK/TIMER5/UART5_TXD/UART3) U14.17(MDC)
MDIO_DATA: R119.2 U5.M17(MDIO_DATA/TIMER6/UART5_RXD/UART) U14.16(MDIO)
MII1_COL: R138.1 U5.H16(GMII1_COL/RMII2_REFCLK/SPI1_SCL)
MII1_CRS_DV: R139.1 U5.H17(GMII1_CRS/RMII1_CRS_DV/SPI1_D0/)
MII1_REFCLK: R28.2 R124.1 R140.1
MII1_RXCLK: R131.1 U5.L18(GMII1_RXCLK/UART2_TXD/RGMII1_RC)
MII1_RXD0: R128.1 U5.M16(GMII1_RXD0/RMII1_RXD0/RGMII1_RD)
MII1_RXD1: R127.1 U5.L15(GMII1_RXD1/RMII1_RXD1/RGMII1_RD)
MII1_RXD2: R126.1 U5.L16(GMII1_RXD2/UART3_TXD/RGMII1_RD2)
MII1_RXD3: R125.1 U5.L17(GMII1_RXD3/UART3_RXD/RGMII1_RD3)
MII1_RXDV: R129.1 U5.J17(GMII1_RXDV/LCD_MEMORY_CLK/RGMII)
MII1_RXERR: R133.1 U5.J15(GMII1_RXERR/RMII1_RXERR/SPI1_D1)
MII1_TXCLK: R134.1 U5.K18(GMII1_TXCLK/UART2_RXD/RGMII1_TC)
MII1_TXD0: U5.K17(GMII1_TXD0/RMII1_TXD0/RGMII1_TD) U14.22(TXD0)
MII1_TXD1: U5.K16(GMII1_TXD1/RMII1_TXD1/RGMII1_TD) U14.23(TXD1)
MII1_TXD2: U5.K15(GMII1_TXD2/DCAN0_RX/RGMII1_TD2/) U14.24(TXD2)
MII1_TXD3: U5.J18(GMII1_TXD3/DCAN0_TX/RGMII1_TD3/) U14.25(TXD3)
MII1_TXEN: U5.J16(GMII1_TXEN/RMII1_TXEN/RGMII1_TC) U14.21(TXEN)
MMC0_CD: P2.19(EMU4) P10.10(CD) R157.1 U5.C15(SPI0_CS1/UART3_RXD/ECAP1_IN_PWM)
MMC0_CLKO: P10.5(CLOCK) R152.2 U5.G17(MMC0_CLK/GPMC_A24/UART3_CTSN/UA)
MMC0_CMD: P10.3(CMD) R151.2 U5.G18(MMC0_CMD/GPMC_A25/UART3_RTSN/UA)
MMC0_DAT0: P10.7(DAT0) R153.2 U5.G16(MMC0_DAT0/GPMC_A23/UART5_RTSN/U)
MMC0_DAT1: P10.8(DAT1) R154.2 U5.G15(MMC0_DAT1/GPMC_A22/UART5_CTSN/U)
MMC0_DAT2: P10.1(DAT2) R150.2 U5.F18(MMC0_DAT2/GPMC_A21/UART4_RTSN/T)
MMC0_DAT3: P10.2(CD/DAT3) R155.2 U5.F17(MMC0_DAT3/GPMC_A20/UART4_CTSN/T)
MMC1_CLK: P8.21(11) R110.2 U5.U9(GPMC_CSN1/GPMC_CLK/MMC1_CLK/PRT) U13.M6(CLK)
MMC1_CMD: P8.20(35) R109.2 U5.V9(GPMC_CSN2/GPMC_BE1N/MMC1_CMD/PR) U13.M5(CMD)
MMC1_DAT0: P8.25(13) R101.2 U5.U7(GPMC_AD0/MMC1_DAT0//////GPIO1_0) U13.A3(DAT0)
MMC1_DAT1: P8.24(37) R102.2 U5.V7(GPMC_AD1/MMC1_DAT1//////GPIO1_1) U13.A4(DAT1)
MMC1_DAT2: P8.5(3) R103.2 U5.R8(GPMC_AD2/MMC1_DAT2//////GPIO1_2) U13.A5(DAT2)
MMC1_DAT3: P8.6(28) R104.2 U5.T8(GPMC_AD3/MMC1_DAT3//////GPIO1_3) U13.B2(DAT3)
MMC1_DAT4: P8.23(12) R105.2 U5.U8(GPMC_AD4/MMC1_DAT4//////GPIO1_4) U13.B3(DAT4)
MMC1_DAT5: P8.22(36) R106.2 U5.V8(GPMC_AD5/MMC1_DAT5//////GPIO1_5) U13.B4(DAT5)
MMC1_DAT6: P8.3(2) R107.2 U5.R9(GPMC_AD6/MMC1_DAT6//////GPIO1_6) U13.B5(DAT6)
MMC1_DAT7: P8.4(27) R108.2 U5.T9(GPMC_AD7/MMC1_DAT7//////GPIO1_7) U13.B6(DAT7)
MODE2: R113.1 R138.2 U14.15(COL/CRS_DV/MODE2)
OSC0_IN: C25.1 R17.1 U5.V10(OSC0_IN) Y2.2
OSC0_OUT: C26.1 R17.2 U5.U11(OSC0_OUT) Y2.1
OSC1_IN: C21.2 U5.A6(OSC1_IN) Y1.1
OSC1_OUT: C22.2 U5.A4(OSC1_OUT) Y1.4
P_BYPASS: C4.2 U2.47(BYPASS)
P_INT_LDO: C3.2 U2.48(INT_LDO)
P_L1: L1.1 U2.20(L1)
P_L2: L2.1 U2.23(L2)
P_L3: L3.1 U2.31(L3)
PHY_VDDCR: C134.1 C136.1 U14.6(VDDCR)
PHY_XTAL1: C143.1 R141.2 R142.1 Y3.1
PHY_XTAL2: R141.1 R143.1 U14.4(XTAL2)
PHYX: C142.1 R143.2 Y3.2
PMIC_INT: R1.2 U2.45(INT) U5.B18(NNMI)
PMIC_PGOOD: U2.26(PGOOD) U5.B15(PORZN) U16.2(A)
PMIC_POWR_EN: U2.9(PWR_EN) U5.C6(PMIC_POWER_EN)
PROC_A15: R18.1 U5.A15(EVENT_INTR0/TIMER4/CLKOUT1/SPI1)
PWR_BUT: P9.9(5) S3.2(B1) S3.4(B2) U2.25(PB_IN)
PWR_LEDR: D1.1(C) R12.2
RBIAS: R144.1 U14.32(RBIAS)
RCLKIN: R140.2 R142.2 U14.5(XTAL1/CLKIN)
REFCLKO: R118.1 R124.2 R131.2 U14.7(RXCLK/PHYAD1)
RXD0/MODE0: R112.1 R128.2 U14.11(RXD0/MODE0)
RXD1/MODE1: R114.1 R127.2 U14.10(RXD1/MODE1)
RXD2/RMIISEL: R117.1 R126.2 U14.9(RXD2/RMIISEL)
RXD3/PHYAD2: R116.1 R125.2 U14.8(RXD3/PHYAD2)
RXDV: R129.2 U14.26(RXDV)
RXER/PHYAD0: R115.1 R133.2 U14.13(RXER/RXD4/PHYAD0)
RXN: C138.1 P5.2(RD-) R121.1 U14.30(RXN)
RXP: C137.1 P5.1(RD+) R120.1 U14.31(RXP)
SPI1_CS0: P9.28(39) U5.C12(MCASP0_AHCLKR/EHRPWM0_SYNCI_O/M) U11.25(AP1)
SPI1_D0: P9.29(15) U5.B13(MCASP0_FSX/EHRPWM0B//SPI1_D0/MM) U11.24(AP0)
SPI1_D1: P9.30(40) U5.D12(MCASP0_AXR0/EHRPWM0_TRIPZONE_IN)
SPI1_SCLK: P9.31(16) U5.A13(MCASP0_ACLKX/EHRPWM0A//SPI1_SCL) U11.23(ACLK)
SYS_5V: C7.2 C8.2 C10.2 C13.2 C17.1 C34.1 P9.7(4) P9.8(29) R71.1 R72.1 R73.1 R74.1 RT1.1 U2.2(VINLDO) U2.7(SYS1) U2.8(SYS2) U2.21(VIN_DCDC1) U2.22(VIN_DCDC2) U2.32(VIN_DCDC3) U2.39(LDO3_IN) U2.42(LDO4_IN) U4.2(IN) U8.2(IN1) U8.3(IN2)
SYS_RESETN: C24.1 C30.1 P2.15(SRST) P9.10(30) R14.2 S1.2(B1) S1.4(B2) U5.A10(NRESET_INOUT) U14.19(NRST) U16.4(Y)
TCT_RCT: C141.1 P5.4(RCT) P5.5(TCT) R137.1
TESTOUT: TP3.1(TP) U5.A3(TESTOUT)
TIMER4: P8.7(4) U5.R7(GPMC_ADVN_ALE/TIMER4/GPIO2_2)
TIMER5: P8.9(5) U5.T6(GPMC_BE0N_CLE/TIMER5/GPIO2_5)
TIMER6: P8.10(30) U5.U6(GPMC_WEN/TIMER6/GPIO2_4)
TIMER7: P8.8(29) U5.T7(GPMC_OEN_REN/TIMER7/EMU4/GPIO2_)
TXCLK: R134.2 U14.20(TXCLK)
TXN: C140.1 P5.6(TD-) R123.1 U14.28(TXN)
TXP: C139.1 P5.3(TD+) R122.1 U14.29(TXP)
U5_H18: R28.1 U5.H18(RMII1_REFCLK/XDMA_EVENT_INTR2/S)
U5_R13: R160.1 U5.R13(GPMC_A0/GMII2_TXEN/RGMII2_TCTL/)
U5_T13: R161.1 U5.T13(GPMC_CSN3/MMC2_CMD/PR1_MDIO_DAT)
UART0_RX: U5.E15(UART0_RXD/SPI1_CS0/DCAN0_TX/I2C) U15.6(1Y)
UART0_TX: U5.E16(UART0_TXD/SPI1_CS1/DCAN0_RX/I2C) U15.5(2A)
UART1_RXD: P9.26(38) U5.D16(UART1_RXD/MMC1_SDWP/DCAN1_TX/I2)
UART1_TXD: P9.24(37) U5.D15(UART1_TXD/MMC2_SDWP/DCAN1_RX/I2)
UART2_RXD: P9.22(36) U5.A17(SPI0_SCLK/UART2_RXD/I2C2_SDA/EH)
UART2_TXD: P9.21(11) U5.B17(SPI0_D0/UART2_TXD/I2C2_SCL/EHRP)
UART4_RXD: P9.11(6) U5.T17(GPMC_WAIT0/GM112_CRS/GPMC_CSN4/)
UART4_TXD: P9.13(7) U5.U17(GPMC_WPN/GMII2_RXERR/GPMC_CSN5/)
USB0_DM: P4.2(D-) U5.N18(USB0_DM) U10.2(D-)
USB0_DP: P4.3(D+) U5.N17(USB0_DP) U10.1(D+)
USB0_ID: P4.4(ID) U5.P16(USB0_ID) U10.3(ID)
USB1_DM: P3.2(P2) U5.R18(USB1_DM) U9.2(D-)
USB1_DP: P3.3(P3) U5.R17(USB1_DP) U9.1(D+)
USB1_DRVVBUS: R53.1 U5.F15(USB1_DRVVBUS/GPIO3_13) U8.4(EN)
USB1_ID: R49.2 U5.P17(USB1_ID)
USB1_OCN: R52.2 U5.T16(GPMC_A10/GMII2_RXD1/RGMII2_RD1/) U8.5(O\C\)
USB1_PWR: C35.1 FB7.1 FB8.2 U8.6(OUT3) U8.7(OUT2) U8.8(OUT1) U9.6(VBUS)
USB1_VBUS: FB8.1 U5.T18(USB1_VBUS)
USB_DC: C1.2 C36.1 P4.1(VB) R159.1 U2.12(USB) U10.6(VBUS)
USR0: Q1.2(5) R76.1 U5.V15(GPMC_A5/GMII2_TXD0/RGMII2_TD0/R)
USR1: Q1.5 R77.1 U5.U15(GPMC_A6/GMII2_TXCLK/RGMII2_TCLK)
USR2: Q2.2(5) R78.1 U5.T15(GPMC_A7/GMII2_RXCLK/RGMII2_RCLK)
USR3: Q2.5 R79.1 U5.V16(GPMC_A8/GMII2_RXD3/RGMII2_RD3/M)
VDCDC1: L1.2 R6.1 U2.19(VDCDC1)
VIO: R7.2 U2.18(VIO) U16.5(VCC)
VLDO1: R5.1 R7.1 R8.1 U2.3(VLDO1)
VREFP_ADC: C31.1 C32.1 C33.1 R27.2 U5.B9(VREFP)
VRTC: C16.1 C105.1 R5.2 R26.1 U5.D7(VDDS_RTC)
WAKEUP: R26.2 U2.13(WAKEUP) U5.C5(EXT_WAKEUP)
WP: R156.2 TP4.1(TP) U7.5(WP)
XDMA_EVENT_INTR0: P2.17(EMU2) R18.2 U6.1(CLK)
YEL_C: P5.11(YELC) R130.2
YELA: P5.12(YELA) R135.1 U14.2(LED2/NINTSEL)
ZQ: R99.2 U12.L8(ZQ)
N21667305: R149.1 U11.49(TEST)
N21757673: C19.1 R10.1 R11.2 U4.4(ADJ)
N21769115: R75.2 S2.1(A1) S2.3(A2)
N22155575: R159.2 U5.P15(USB0_VBUS)
N22248684: R167.1 Y4.3(CLK)
N22248838: R21.1 U6.5(Q)
N22287501: R162.1 U3.4(Y)
N22287555: U3.2(A) U5.R14(GPMC_A4/GMII2_TXD1/RGMII2_TD1/R)
N22420400: TP5.1(TP) U2.4(BAT1) U2.5(BAT2)
N22420444: TP6.1(TP) U2.6(BAT_SENSE)
N22420447: TP7.1(TP) U2.11(TS)
N22488252: TP9.1(TP) U5.E17(UART0_RTSN/UART4_TXD/DCAN1_RX/I)

Pads without a net: D6 6 7 9 10; D7 6 7 9 10; J1 2 3 6; NOREF#10 1; NOREF#14 1; NOREF#17 1; NOREF#26 1; NOREF#27 1; NOREF#29 1; P1 3; P2 6; P5 7; P6 2; U2 14 15 16 17 33 34 35 36 37 38 44; U3 1; U5 E18 F16 M5 M15 P18; U9 3 5; U10 5; U11 26 28; U12 J1 J9 L1 L9; U13 A1 A2 A6 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H5 H12 H13 H14 J1 J2 J3 J5 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U16 1; Y1 2 3

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 796 vias
v2: diameter 0.254, hole 0.152, TOP to BOTTOM, 27 vias
v3: diameter 0.559, hole 0.305, TOP to BOTTOM, 30 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
DGND: length 483.7
  TOP w0.121: U13.N2 v2(26.85,44.91)
  TOP w0.191: R118.2 31.43,26.48 32.95,26.48 v1(33.02,26.54) ; U10.4 v1(14.1,41.41)
  TOP w0.203: v1(8.88,44.77) Q2.1 8.88,46.21 9.02,46.35 10.03,46.35 10.17,46.5 Q2.4 ; U13.H10 v2(29.6,40.13) ; Q1.4 13.67,46.5 13.53,46.35 12.51,46.35 12.37,46.21 Q1.1 v1(12.37,44.77) ; U13.K8 v2(28.09,41.66) ; U13.G5 v2(30.09,43.66) ; U2.30 24.46,15.04 24.26,15.24 v3(23.88,15.24) ; U13.C4 v2(31.6,43.16) ; U13.E7 v2(31.6,42.16) ; U13.P6 v2(26.05,42.66) ; U13.N5 v2(26.85,43.41) ; U2.41 v1(23.46,19.62) ; v2(26.04,43.66) U13.P4
  TOP w0.254: U11.9 61.21,39.76 v3(61.59,39.37) ; U5.J10 v1(44.92,28.41) U5.H10 ; U5.M12 v1(44.12,30.81) U5.L11 ; v1(47.32,28.41) U5.J8 ; 59.15,35.65 59.05,35.56 v1(58.42,35.56) ; 59.15,35.65 U11.16 ; 59.15,35.65 U11.17 ; v1(44.92,30.01) U5.K10 ; v1(44.92,30.01) U5.K11 ; v1(44.92,30.01) U5.L10 ; U5.N10 v1(44.92,32.41) U5.N11 ; U11.61 61.25,43.27 61.59,42.93 v3(61.59,41.91) ; v3(64.14,41.91) 64.75,42.52 U11.54 ; v1(43.32,26.81) U5.G12 43.88,27.05 44.36,27.05 U5.G11 ; U5.M14 v1(41.72,31.61) U5.N14 ; U5.A1 v1(52.52,21.72) ; U5.M7 v1(48.12,30.81) U5.M6 ; v3(61.59,41.91) 60.75,42.76 U11.62 ; v3(61.59,41.91) 60.71,41.91 60.25,42.37 U11.63 ; U11.53 65.25,42.06 v3(65.41,41.91) ; U5.V1 v1(52.52,36.7) ; U11.19 60.75,35.12 60.45,34.82 v1(60.45,34.8) 60.25,35 U11.18 ; v1(60.7,27.17) U12.E1 60.18,27.69 59.69,27.69 59.31,27.3 59.31,26.96 U12.G1 ; v1(72.14,38.99) 72.52,39.37 D7.3 ; U12.D1 v1(60.7,27.97) U12.E2 ; D6.3 v1(72.14,34.92) ; U5.V18 v1(38.1,36.01) ; U5.J11 v1(44.12,28.41) ; v1(44.92,31.61) U5.M10 ; U11.8 61.21,40.25 v3(61.59,40.64) ; v1(66.3,27.97) U12.E8 ; U5.L13 v1(43.32,30.81) U5.L12 ; D7.8 v1(78.99,39.37) ; U12.B9 v1(67.1,30.37) U12.A9 ; v1(46.52,30.01) U5.K9 ; v1(59.9,18.36) U12.T1 ; v1(59.9,21.56) U12.M1 ; v1(59.9,19.96) U12.P1 ; U5.J6 v1(48.92,28.41) U5.H6 ; v1(66.3,26.37) U12.G8 ; v1(67.1,18.36) U12.T9 ; D6.8 v1(78.99,34.92) ; U12.F9 v1(67.1,26.37) U12.G9 ; U5.K7 U5.J7 v1(48.12,28.41) ; v1(59.9,30.37) U12.B1 ; U5.F8 v1(46.52,26.81) U5.G9 ; U5.H7 v1(48.12,27.61) ; v1(60.7,23.96) U12.J2 ; U5.G8 v1(46.52,27.61) U5.H9 ; U5.M8 v1(46.52,31.61) U5.M9 ; v1(61.5,30.37) U12.B3 ; v1(48.12,32.41) U5.N7 ; v1(66.3,28.77) U12.D8 ; v1(46.52,28.41) U5.J9 ; v1(43.32,27.61) U5.H12 ; v1(47.32,27.61) U5.H8 ; v1(67.1,21.56) U12.M9 ; v1(66.3,23.96) U12.J8 ; U5.A18 v1(38.52,22.01) ; v1(67.1,19.96) U12.P9
  TOP w0.381: R84.2 v1(59.37,45.72) ; R84.2 R80.2 R81.2 v1(57.47,45.72) ; R84.2 R82.2 R83.2 R85.2 R86.2 R87.2 R88.2 R89.2 R90.2 R91.2 R92.2 R93.2 ; Y4.2 41.71,40.82 ; Y4.2 40.56,40.82 ; Y4.2 41.15,41.53 ; C61.1 v1(72.71,48.26) ; 14.92,19.37 C3.1 C18.2 C16.2 ; v1(36.07,8.57) 36.07,8.76 36.39,9.08 R25.2 ; S1.3 v1(6.86,52.24) ; v1(71.75,45.72) R95.2 R94.2 R93.2 ; v1(55.24,39.12) C160.2 55.63,39.88 55.88,40.13 55.88,40.64 56.13,40.89 C163.2 ; C96.1 C155.1 55.63,11.68 v1(56.26,11.68) ; C169.2 56.9,36.83 57.15,37.08 v1(57.15,37.34) ; v1(78.49,42.38) S2.2 S2.4 ; R29.2 v1(44.96,43.56) ; C166.2 v1(52.7,41.66) ; v1(34.29,6.48) C29.2 ; U3.3 v1(40.97,45.72) ; R165.2 C27.2 v1(45.09,12.7) ; C37.2 28.77,21.4 v1(29.46,20.7) ; C156.2 54.86,44.45 54.61,44.2 54.61,43.69 54.36,43.43 C167.2 v1(53.98,42.67) ; v1(6.99,17.14) R10.2 C19.2 ; S3.1 v1(7.62,42.71) S3.3 ; v1(30.16,10.16) 30.64,9.69 U16.3 ; S1.1 v1(9.02,52.24) ; v1(81.28,39.62) C153.2 81.66,38.23 C154.2 v1(83.19,39.12) ; R93.2 v1(69.85,45.72) ; C168.2 52.7,45.47 53.72,46.48 C165.2 55.63,46.48 55.88,46.74 55.88,47.24 56.13,47.5 C57.1 v1(56.52,48.26) ; C173.2 v1(74.68,46.48) ; v1(53.98,41.66) C157.2 ; 22.35,8.51 C9.1 22.99,8 v1(22.99,7.11) v1(22.35,7.11) 22.35,8.51 ; v1(24.19,7.11) 24.19,8.06 C12.1 24.83,8.45 v1(24.83,7.11) v1(24.19,7.11)
  TOP w0.508: v1(64.52,15.49) 64.52,13.78 C34.2 63.63,13.91 v1(63.63,15.49) ; v1(29.97,18.03) v1(29.97,17.4) 29.97,16.13
  TOP w0.635: 14.92,19.37 v1(13.97,19.37) C1.1
  TOP w0.762: C11.1 C55.1
  LYR2_GND w0.889: P8.1 20.65,51.13 ; P8.1 20.65,49.2 ; P8.1 18.72,51.13 ; P8.1 18.72,49.2 ; 72.29,5.18 P9.44 ; P9.44 73.76,5.18 ; P9.44 73.76,3.71 ; P9.44 72.29,3.71 ; 74.83,3.71 P9.46 ; P9.46 76.3,3.71 ; P9.46 74.83,5.18 ; P9.46 76.3,5.18 ; 16.41,26.13 P5.8 ; P5.8 17.88,24.67 ; P5.8 17.88,26.13 ; P5.8 16.41,24.67 ; TP1.1 59.79,11.53 ; TP1.1 58.32,10.06 ; TP1.1 59.79,10.06 ; TP1.1 58.32,11.53 ; 18.72,2.87 P9.1 20.65,2.87 ; 72.56,21.11 P3.4 ; P3.4 74.12,19.56 ; P3.4 74.12,21.11 ; P3.4 72.56,19.56 ; 16.54,7.39 TP8.1 ; TP8.1 16.54,8.86 ; TP8.1 18.01,8.86 ; TP8.1 18.01,7.39 ; P1.2 6.27,9.53 ; P1.2 5.18,7.42 ; P1.2 4.09,9.53 ; P1.2 5.18,11.63 ; 41.58,8.59 J1.1 ; J1.1 43.51,6.65 ; J1.1 41.58,6.65 ; 73.76,2.64 P9.43 72.29,2.64 ; 18.95,51.97 P8.2 20.42,51.97 ; 18.95,3.71 P9.2 ; P9.2 20.42,5.18 ; P9.2 18.95,5.18 ; P9.2 20.42,3.71 ; 74.83,2.64 P9.45 76.3,2.64
  BOTTOM w0.191: P6.10 v1(82.8,25.15) ; v1(44.92,24.41) 44.92,24.3 45.71,23.5 C88.2 ; P6.13 79.16,25.75 v1(78.99,25.91) ; v1(82.8,26.73) 82.11,26.73 81.72,26.35 P6.16 ; P6.7 v1(78.99,24.55) ; v1(29.21,32.7) 29.21,32.35 29.34,32.23 30.86,32.23 30.99,32.1 R115.2 ; P6.4 81.72,23.95 82.04,23.62 v1(82.8,23.62)
  BOTTOM w0.203: v1(49.72,25.21) 49.43,25.5 49.26,25.5 48.81,25.94 C100.2
  BOTTOM w0.254: U6.4 44.79,12.41 v1(45.09,12.7) ; C129.2 31.11,41.4 31.6,41.88 v2(31.6,42.16) ; C155.1 56.01,11.94 v1(56.26,11.68) ; C70.1 42.63,26.12 v1(43.32,26.81) v1(43.32,27.61) ; C130.2 v1(34.29,40.64) ; C127.2 v1(25.4,40.64) ; v2(28.09,41.66) 28.09,41.94 28.57,42.42 C128.2 ; v1(54.48,10.16) 53.21,10.16 52.83,10.54 52.83,11.43 52.08,12.18 U15.4 50.28,12.18 50.04,11.94 50.04,10.92 50.28,10.68 U15.1
  BOTTOM w0.305: C99.2 v1(48.12,27.61) ; C63.2 44.01,26.81 v1(43.32,26.81) ; C48.2 47.83,28.7 v1(48.12,28.41) ; v1(48.92,28.41) 48.92,29.1 C98.2 ; C50.2 v1(47.32,27.61) ; v1(46.52,26.81) 46.23,26.52 C72.1 ; v1(46.52,30.01) 45.83,30.01 C47.2 ; C41.2 41.72,32.3 v1(41.72,31.61) 41.72,30.92 C66.2 ; C60.1 v1(43.32,27.61) ; C73.1 v1(48.12,32.41) 47.43,32.41 C43.2 ; v1(46.52,31.61) 46.23,31.9 C42.2 ; v1(48.12,30.81) C97.2 ; v1(44.92,30.01) 44.63,29.72 C46.2 ; C94.2 v1(44.12,30.81) ; U9.4 80.48,18.91 v1(80.62,19.05) ; v1(44.92,28.41) 45.58,28.41 C49.2
  BOTTOM w0.381: C92.2 C105.2 C89.2 C91.2 C90.2 C59.2 ; C92.2 C104.2 v1(49.21,18.41) ; C92.2 v1(48.26,18.41) ; C132.2 24.77,29.84 v3(25.08,30.16) 25.4,29.84 C136.2 C134.2 ; C132.2 24,30.99 v3(24.13,31.11) ; C132.2 C131.2 ; C68.1 v1(48.92,38.1) ; v1(31.75,27.94) R116.2 R117.2 ; C28.2 v1(57.15,27.17) C109.2 ; C121.2 v1(69.85,19.16) ; C40.1 33.02,28.07 v1(33.02,27.37) 33.02,26.99 ; C40.1 33.78,28.07 C52.2 ; C40.1 33.78,28.83 C51.2 ; C164.2 v1(50.16,41.66) ; C144.2 61.09,40.13 v3(61.59,40.64) ; v1(41.53,38.35) 41.42,38.25 41.42,37.88 41.32,37.78 C80.2 ; v1(33.02,20.32) 33.02,20.33 ; 33.02,20.33 33.02,21.21 C62.1 33.78,21.21 33.78,20.33 ; 33.02,20.33 33.78,20.33 ; v1(21.91,26.35) 23.05,26.35 C142.2 ; C54.2 C79.2 C69.1 ; C54.2 C44.2 ; C54.2 v1(36.83,26.81) ; 53.98,16.7 C95.1 53.09,18.16 v1(52.83,18.41) 52.32,18.41 52.07,18.67 C101.2 ; 53.98,16.7 C102.2 ; 53.98,16.7 C103.2 55.31,16.7 v1(55.37,16.76) ; C161.2 C166.2 v1(52.7,41.66) ; C38.2 C67.2 v1(33.02,35.56) ; v1(30.16,10.16) C30.2 C24.2 ; P4.5 7.11,45.73 7.23,45.86 8.88,45.86 ; v1(36.83,24.77) C82.2 C83.2 C85.2 ; U7.2 29.91,21.91 29.46,21.46 v1(29.46,20.7) ; 33.78,20.33 C64.2 ; v1(66.3,23.96) U12.J8 C123.2 ; P2.4 v1(36.07,8.57) ; C139.2 v1(10.67,31.75) ; C115.2 v1(69.85,29.57) ; P2.20 39.56,18.73 40.53,17.76 40.53,16.27 40.24,15.98 39.5,15.98 39.35,16.13 38.01,16.13 P2.16 v1(36.07,16.19) ; C159.2 39.69,40.51 v1(40.32,39.88) ; R96.1 v1(69.85,23.16) ; v1(49.21,18.41) 50.87,18.41 51.12,18.66 R54.1 ; v1(49.21,18.41) R164.2 ; C108.2 v1(57.15,29.57) ; C86.2 37.61,35.81 37.81,36.01 v1(38.1,36.01) 38.3,36.01 38.61,36.32 C71.1 ; C173.2 v1(74.68,46.48) ; 65.41,43.31 v3(65.41,41.91) ; 65.41,43.31 66.67,43.31 ; 65.41,43.31 64.14,43.31 v3(64.14,41.91) ; v1(69.85,16.82) 69.84,16.83 C122.1 ; R99.1 v1(69.85,21.96) ; C58.2 C106.2 43.96,37.32 44.32,36.96 v1(45.72,36.96) C56.1 ; C107.2 v1(57.15,31.17) ; v1(36.83,30.81) C87.2 C45.2 ; C117.2 v1(69.85,25.57) ; C17.2 v1(6.99,15.88) ; v1(40.97,45.72) 40.97,47.04 40.51,47.5 C158.2 ; R49.1 37.15,33.97 36.83,33.66 v1(36.83,33.15) 36.83,32.77 37.19,32.41 C84.2 ; R145.2 v1(31.75,34.61) ; C52.2 33.02,26.99 ; C52.2 33.78,25.91 C39.1 ; 33.02,26.99 v1(33.02,26.54) 33.02,25.91 C39.1 ; C147.2 v3(65.41,38.1) ; v1(6.22,29.46) 5.4,29.46 R136.1 5.4,30.23 v1(6.22,30.23) ; v1(6.22,29.46) R130.1 R135.2 ; v1(6.22,29.46) v1(6.22,30.23) ; C151.2 R148.2 68.2,35.69 68.58,35.31 v1(68.58,34.8) ; R132.1 v1(6.22,30.23) ; C126.1 v1(23.5,39.88) ; C118.1 v1(69.85,32.7) ; R144.2 v1(18.73,28.26) ; C114.2 v1(69.85,31.17) ; C61.1 v1(72.71,48.26) ; v1(12.37,44.77) 12.37,46.32 12.6,46.55 R76.2 13.4,46.55 13.65,46.29 13.65,45.78 13.9,45.53 R77.2 ; 8.88,45.86 8.88,46.32 9.1,46.55 R78.2 ; 8.88,45.86 v1(8.88,44.77) ; v1(72.14,34.92) 72.44,34.62 72.44,34.12 72.26,33.94 P10.9 ; C35.2 v1(81.89,19.68) ; C57.1 v1(56.52,48.26) ; v1(35.56,33.91) 35.05,33.91 C78.2 ; v1(32.38,37.15) C77.2 ; v1(47.32,38.1) C81.2 ; C149.2 68.33,44.7 v1(68.58,44.7) ; v1(10.79,44.77) R79.2 ; C135.2 v1(28.45,33.66) ; v1(53.98,41.66) C157.2 C172.2 ; v1(28.26,26.35) 27.11,26.35 C143.2 ; v1(58.42,35.56) 58.93,35.56 C145.2 ; R10.2 v1(6.99,17.14) 5.46,17.14 4.83,16.51 R12.1 ; C137.2 v1(10.67,34.29) ; C140.2 v1(10.67,27.94) ; v1(33.02,24.38) 33.27,24.13 C53.2 33.78,25.15 C39.1 ; C120.2 v1(69.85,20.76) ; v1(82.23,34.54) 83,33.78 P10.6 ; C152.2 v1(26.04,23.11) ; C150.2 65.91,41.15 v3(65.41,40.64) ; v3(25.08,32.07) 24.77,32.07 24.38,32.45 C133.1 ; v1(14.1,41.41) 14.09,41.4 C36.2 ; C116.2 v1(69.85,27.97) ; C138.2 v1(10.67,33.02) ; P2.8 36.13,11.11 v1(36.07,11.18) 36.07,12.13 36.32,12.38 P2.10 P2.12 ; C141.2 v1(10.67,30.48) ; v1(62.99,21.21) C124.2 R100.2 ; C119.2 v1(69.85,24.36) ; v1(50.16,38.1) 50.52,37.74 C74.1 ; C110.2 v1(57.15,25.57) ; C113.2 v1(57.15,19.16) ; C111.2 v1(57.15,23.16) ; U8.1 v1(75.56,13.63) ; C125.2 v1(32.38,48.26) ; R22.1 v1(57.15,28.41) ; C112.2 v1(57.15,20.76) ; R53.2 v1(76.81,19.68) ; FB3.2 44.2,14.86 v1(44.2,14.1) v1(43.43,14.1) 43.43,14.86 FB3.2
  BOTTOM w0.635: v1(13.97,19.37) 13.97,18.41 ; 13.97,18.41 U4.5 ; 13.97,18.41 13.97,17.14 ; 16.45,14.61 14.22,14.61 13.97,14.86 13.97,15.88 ; 13.97,17.14 13.97,15.88 ; 13.97,17.14 16.45,17.14 ; 13.97,15.88 U4.7 ; P1.2 5.18,11.91 5.71,12.45 C2.1
  BOTTOM w0.762: P9.45 P9.46 ; P8.1 P8.2 ; P9.1 P9.2
  vias: v3(21.34,15.24) v3(21.34,13.97) v3(22.61,15.24) v3(22.61,13.97) v3(25.08,31.11) v3(26.04,31.11) v3(61.59,38.1) v3(62.87,41.91) v3(62.87,40.64) v3(62.87,39.37) v3(62.87,38.1) v3(64.14,40.64) v3(64.14,39.37) v3(64.14,38.1) v3(65.41,39.37) v3(78.71,15.24) v3(78.71,13.97) v3(79.98,15.24) v3(79.98,13.97)
GND_EARTH: length 186.9
  TOP w0.889: 12.84,1.41 MTG1.1 ; MTG1.1 16.37,1.41 ; MTG1.1 12.84,4.94 ; MTG1.1 16.37,4.94 ; 12.84,53.2 MTG3.1 ; MTG3.1 16.37,49.67 ; MTG3.1 12.84,49.67 ; MTG3.1 16.37,53.2 ; MTG2.1 82.41,8.12 ; MTG2.1 82.41,4.58 ; MTG2.1 78.88,4.58 ; MTG2.1 78.88,8.12 ; 78.88,50.03 MTG4.1 ; MTG4.1 78.88,46.49 ; MTG4.1 82.41,46.49 ; MTG4.1 82.41,50.03
  LYR2_GND w0.889: MTG3.1 16.37,49.67 ; MTG3.1 12.84,53.2 ; MTG3.1 16.37,53.2 ; MTG3.1 12.84,49.67 ; 78.88,8.12 MTG2.1 ; MTG2.1 82.41,4.58 ; MTG2.1 78.88,4.58 ; MTG2.1 82.41,8.12 ; 12.84,1.41 MTG1.1 ; MTG1.1 12.84,4.94 ; MTG1.1 16.37,4.94 ; MTG1.1 16.37,1.41 ; 78.88,46.49 MTG4.1 ; MTG4.1 82.41,50.03 ; MTG4.1 82.41,46.49 ; MTG4.1 78.88,50.03
  LYR5_PWR w0.889: MTG1.1 16.37,1.41 ; MTG1.1 16.37,4.94 ; MTG1.1 12.84,4.94 ; MTG1.1 12.84,1.41 ; MTG4.1 82.41,46.49 ; MTG4.1 78.88,50.03 ; MTG4.1 78.88,46.49 ; MTG4.1 82.41,50.03 ; 78.88,4.58 MTG2.1 ; MTG2.1 78.88,8.12 ; MTG2.1 82.41,4.58 ; MTG2.1 82.41,8.12 ; 12.84,53.2 MTG3.1 ; MTG3.1 16.37,53.2 ; MTG3.1 12.84,49.67 ; MTG3.1 16.37,49.67
  BOTTOM w0.381: v1(1.91,29.46) 2.86,29.46 R136.2 2.86,30.23 v1(1.91,30.23) ; 77.82,45.24 75.91,45.24 75.64,44.97 P10.11 73.96,44 72.76,42.8 71.75,42.8 71.11,42.15 P10.15 P10.16 71.09,35.14 70.8,34.86 70.8,33.08 71.63,32.26 74.68,32.26 75.26,31.67 P10.12
  BOTTOM w0.889: 78.88,46.49 MTG4.1 ; MTG4.1 82.41,46.49 ; MTG4.1 78.88,50.03 ; MTG4.1 82.41,50.03 ; MTG3.1 16.37,49.67 ; MTG3.1 12.84,53.2 ; MTG3.1 12.84,49.67 ; MTG3.1 16.37,53.2 ; 78.88,4.58 MTG2.1 ; MTG2.1 82.41,4.58 ; MTG2.1 82.41,8.12 ; MTG2.1 78.88,8.12 ; 12.84,4.94 MTG1.1 ; MTG1.1 12.84,1.41 ; MTG1.1 16.37,1.41 ; MTG1.1 16.37,4.94
GND_OSC0: length 5
  TOP w0.381: U5.V11 44.52,36.48 44.32,36.68 44.32,38.48 44.96,39.12 R29.1 v1(44.13,39.88)
GND_OSC1: length 10.4
  TOP w0.254: v1(51.12,17.78) 51.12,18.22 50.04,19.3 50.04,21.46 49.32,22.18 U5.A5
  BOTTOM w0.381: 51.12,15.68 C22.1 v1(51.75,14.86) ; 51.12,15.68 v1(51.12,17.78) ; 51.12,15.68 C21.1 v1(50.48,14.86)
GNDA_ADC: length 46.8
  TOP w0.254: v1(47.32,25.21) U5.E8
  TOP w0.305: 46.12,21.97 U5.A9
  TOP w0.381: C93.2 45.85,17.27 46.48,17.91 46.48,21.59 46.12,21.95 46.12,21.97 ; C93.2 v1(45.09,16.51) ; C93.2 C33.2 C31.2 C32.2
  LYR4 w0.381: v1(47.32,25.21) 46.29,25.21 45.85,24.77 45.85,23.24 46.48,22.61 46.48,20.32 45.09,18.92 v1(45.09,16.51) 46.1,16.51 53.85,8.76 55.88,8.76 56.52,8.13 56.52,3.94 57.28,3.17 59.05,3.17 P9.34
  BOTTOM w0.381: v1(45.09,16.51) 45.09,16.89 44.84,17.14 FB3.1
VBUS: length 5.3
  BOTTOM w0.508: P3.1 71.18,11.18 FB7.2
VDD_1V8: length 39.8
  TOP w0.203: 24.27,19.81 23.82,19.36 23.82,18.87 23.86,18.83 U2.40
  TOP w0.254: U5.E9 U5.D10 v1(44.92,25.21) ; v1(40.12,34.01) U5.R16 ; v1(40.12,32.41) U5.N16
  TOP w0.381: v1(26.92,17.72) v1(26.92,18.35) 25.46,19.81 24.27,19.81 23.77,20.32 13.34,20.32 11.94,18.92 R9.2
  LYR3 w0.381: v1(26.92,17.72) v1(26.92,18.35)
  BOTTOM w0.305: v1(40.12,34.01) 38.89,35.24 C86.1 ; C88.1 45.61,24.52 v1(44.92,25.21)
  BOTTOM w0.381: v1(54.48,36.2) 55.57,36.2 FB5.2 55.56,35.56 v1(54.48,35.56) ; v1(33.02,33.91) 33.53,33.91 C78.1 33.4,33.27 v1(33.02,33.27) 33.02,32.39 FB1.1 ; v1(26.92,18.35) 26.04,18.35 C14.2 26.04,17.72 v1(26.92,17.72) v1(26.92,18.35) ; 45.09,14.99 45.34,15.24 FB2.2 46.35,14.35 46.1,14.1 v1(45.85,14.1) v1(45.09,14.1) 45.09,14.99
VDD_3V3A: length 127.3
  TOP w0.203: U2.43 22.66,18.81 22.36,19.11 v1(22.36,19.62)
  TOP w0.254: U5.N5 v1(49.72,31.61) ; U5.P13 v1(42.52,33.21) ; U5.E10 v1(44.92,26.01) U5.E11 v1(44.12,25.21) U5.E12 v1(43.32,25.21) U5.E13 ; U5.P8 U5.P7 v1(48.12,33.21) ; U5.P6 v1(48.92,33.21) ; U5.G14 v1(41.72,26.81) U5.F14 ; v1(40.92,34.01) U5.R15 ; U5.H14 v1(41.72,28.41) U5.J14 ; U5.K14 v1(42.52,30.01) U5.L14 ; v1(40.92,32.41) U5.N15 ; U5.P12 v1(43.32,33.21) ; U5.P11 v1(44.92,33.21) U5.P10 ; U5.P5 v1(49.72,33.21)
  TOP w0.381: C61.2 v1(72.71,45.72) ; R3.1 R4.1 ; R4.1 v1(26.99,23.11) ; R4.1 C37.1 ; C27.1 v1(45.09,10.16) ; U3.5 39.67,45.75 v1(39.69,45.73) ; v1(39.69,43.18) 39.5,42.99 Y4.4 ; C57.2 v1(56.52,45.72)
  LYR4 w0.381: v1(83.16,19.68) 82.4,20.45 75.18,20.45 73.34,22.29 73.34,36.39 70.17,39.56 70.17,45.09 v1(70.8,45.72)
  BOTTOM w0.254: 45.09,10.45 v1(45.09,10.16) ; 45.09,10.45 U6.8 ; 45.09,10.45 45.09,11.1 ; U6.7 45.09,11.1 ; 45.09,11.1 45.09,11.56 45.28,11.76 U6.6
  BOTTOM w0.305: v1(40.92,32.41) 39.92,31.41 39.81,31.41 39.21,30.81 C87.1 ; v1(44.92,26.01) 45.43,25.5 C72.2 ; v1(41.72,28.41) 41.72,27.72 C60.2 41.72,27.5 v1(41.72,26.81) 41.72,26.12 C70.2 ; C66.1 42.63,30.12 v1(42.52,30.01) ; v1(44.92,33.21) 45.61,33.9 C56.2
  BOTTOM w0.381: v1(56.52,45.72) C57.2 R56.1 R55.1 ; 26.99,21.4 27.43,20.95 U7.4 ; 26.99,21.4 C152.1 R156.1 ; 26.99,21.4 v1(26.99,23.11) ; C77.1 34.8,36.77 C67.1 ; C77.1 35.62,37.59 v1(36.08,37.59) ; C77.1 35.5,36.83 v1(36.08,36.83) ; v1(22.36,19.62) 22.36,19.25 21.91,18.8 C15.2 ; R69.1 R68.1 R67.1 ; R69.1 R70.1 C61.2 v1(72.71,45.72) ; R69.1 v1(70.8,45.72) ; R55.1 R59.1 R57.1 R58.1 R60.1 R61.1 R62.1 R63.1 R64.1 R65.1 R66.1 R67.1 ; R55.1 v1(58.42,45.72) ; C38.1 C67.1 ; C67.1 v1(35.56,35.56) ; R14.1 v1(30.16,12.06) ; C59.1 v1(43.5,20.95) ; v1(21.59,23.11) R1.1 20.89,22.42 20.45,21.97 15.37,21.97 12.17,18.77 12.17,14.84 11.94,14.61 10.86,14.61 ; C71.2 v1(36.83,36.83) ; R52.1 v1(83.16,19.68) ; R67.1 v1(68.9,45.72) ; C159.1 v1(39.69,43.18) ; C73.2 49.83,31.72 v1(49.72,31.61) ; v1(39.69,45.73) C158.1
VDD_3V3AUX: length 19.6
  TOP w0.121: U2.1 19.79,17.81 19.18,18.41 v1(18.8,18.41) C18.1 ; D1.2 v1(5.59,15.88)
  LYR3 w0.133: v1(5.59,15.88) 5.59,17.02 6.35,17.78 10.54,17.78 11.18,18.41 v1(18.8,18.41)
VDD_3V3B: length 122.9
  TOP w0.203: U13.M4 v2(28.09,43.66) ; U13.C6 v2(31.6,42.66) U13.E6 ; U13.K9 v2(28.09,41.16) ; U13.J10 v2(29.09,40.13) ; U13.N4 v2(26.85,43.91) ; U13.F5 v2(30.6,43.66) ; v2(26.04,44.16) U13.P3 ; v2(26.04,43.16) U13.P5
  TOP w0.254: v1(28.45,30.87) 28,30.87 U14.12
  TOP w0.381: R157.2 v1(70.8,42.67) ; v1(39.37,38.42) 37.78,40.01 36.32,40.01 34.29,42.04 v1(34.29,43.18) ; C29.1 v1(34.29,9.84) 34.86,10.41 36.83,10.41 37.47,11.05 37.47,12.64 37.21,12.89 R23.1 36.83,14.1 ; R119.1 v1(31.75,33.66) ; v1(81.28,40.89) R150.1 R155.1 R151.1 v1(83.19,40.89) 83.57,40.89 83.82,40.64 83.82,37.46 83.57,37.21 C154.1 81.66,37.21 C153.1 v1(81.28,34.54) R154.1 R153.1 R152.1 v1(83.19,34.54) ; R166.2 74.17,26.16 v1(74.42,25.91)
  LYR3 w0.381: v1(34.29,9.84) 35.03,9.1 41.11,9.1 42.8,10.79 54.74,10.79 v1(55.37,10.16)
  LYR4 w0.381: v1(55.37,10.16) 52.58,12.95 v1(52.58,14.86)
  LYR5_PWR w0.889: P9.4 22.96,5.18 ; P9.4 22.96,3.71 ; P9.4 21.49,5.18 ; P9.4 21.49,3.71 ; 21.49,2.64 P9.3 22.96,2.64
  BOTTOM w0.191: R112.2 30.99,31.15 30.86,31.27 28.86,31.27 v1(28.45,30.87)
  BOTTOM w0.254: U15.8 55.13,10.68 C155.2 55.11,11.18 U15.7 ; C130.1 v1(34.29,43.18) ; v2(28.09,41.16) 28.57,41.16 28.82,41.4 C128.1 29.21,40.76 29.09,40.64 v2(29.09,40.13) ; v2(31.6,42.66) 31.11,42.66 30.87,42.42 C129.1 30.48,43.06 30.6,43.18 v2(30.6,43.66) ; v2(26.04,43.16) 25.63,43.16 25.4,42.93 C127.1
  BOTTOM w0.381: R119.1 v1(31.75,33.66) ; R163.1 47.94,14.54 48.26,14.22 51.94,14.22 v1(52.58,14.86) ; R101.1 v1(48.9,45.72) ; R109.1 v1(42.55,45.72) ; R104.1 v1(27.3,45.72) ; R108.1 v1(24.77,45.72) ; R106.1 v1(43.81,45.72) ; R11.1 7.75,18.03 8,17.78 8.51,17.78 8.76,17.53 C20.1 v1(9.53,17.14) 10.86,17.14 ; v1(28.45,30.87) 26.16,33.15 C135.1 ; R114.2 R112.2 ; v1(83.19,40.89) 83.71,41.42 83.71,43.97 83.7,43.99 P10.4 ; R103.1 v1(26.04,45.72) ; C155.2 v1(55.37,10.16) ; R110.1 v1(45.09,45.72) ; R105.1 v1(47.62,45.72) ; v1(39.37,38.42) R158.1 ; R102.1 v1(46.35,45.72) ; R111.1 v1(29.21,48.26) ; R107.1 v1(23.5,45.72) ; P2.5 v1(34.29,9.84) ; C126.2 v1(23.5,43.94)
  BOTTOM w0.762: P9.3 P9.4
  vias: v1(25.72,35.88)
VDD_5V: length 25.5
  TOP w0.203: U2.10 18.92,13.84
  LYR4 w0.762: P1.1 11.18,6.73 11.81,6.1 23.11,6.1 P9.6
  BOTTOM w0.635: C2.2 10.79,12.45 11.18,12.06 P1.1
  BOTTOM w0.762: P9.5 P9.6
VDD_ADC: length 31.5
  TOP w0.254: v1(47.32,24.41) U5.D8
  TOP w0.381: v1(45.85,20.95) 45.84,20.95 45.84,20.09 R27.1 45.09,19.34 C93.1 45.72,18.29 v1(45.85,18.41)
  LYR3 w0.381: v1(47.32,24.41) 46.71,25.02 46.23,25.02 45.85,24.64 v1(45.85,20.95)
  LYR4 w0.381: v1(45.85,18.41) 45.85,17.65 54.1,9.4 56.13,9.4 57.15,8.38 57.15,5.08 P9.32
  BOTTOM w0.381: FB2.1 46.35,17.14 45.85,17.65 v1(45.85,18.41)
VDD_CORE: length 57.4
  TOP w0.254: U5.F7 v1(48.12,26.01) ; U5.L6 v1(48.92,30.01) U5.K6 ; U5.K12 v1(44.12,30.01) ; U5.L7 v1(47.32,30.01) U5.K8 ; v1(48.12,26.81) U5.G7 ; U5.N12 v1(43.32,31.61) U5.N13 ; U5.G6 v1(48.92,26.81) U5.F6 ; v1(47.32,30.81) U5.L8 ; U5.N9 v1(46.52,32.41) U5.N8 ; U5.J12 v1(43.32,28.41) ; U5.M11 v1(44.92,30.81) ; U5.H11 v1(44.12,27.61) ; U5.M13 v1(42.52,31.61) ; v1(46.52,30.81) U5.L9 ; U5.G10 v1(44.92,27.61)
  LYR4 w0.508: 32.13,25.15 31.5,25.15 31.11,24.77 31.11,23.37 30.73,22.99 30.73,19.18 31.11,18.8 31.11,14.99 v1(29.21,13.08) v1(28.57,13.08) ; 32.13,25.15 v1(32.13,24.77) ; 32.13,25.15 v1(32.13,25.4)
  BOTTOM w0.305: v1(48.92,26.81) v1(48.12,26.81) v1(48.12,26.01) 47.43,26.01 C50.1 ; v1(43.32,31.61) v1(42.52,31.61) 42.52,32.3 C41.1 ; C43.1 v1(47.32,30.81) ; C42.1 45.83,32.81 46.12,32.81 v1(46.52,32.41) ; v1(44.92,27.61) 45.03,27.5 C49.1 ; C45.1 38.73,29.91 38.93,29.91 39.83,30.81 v1(40.12,30.81) ; v1(46.52,30.81) 45.83,30.81 C47.1 45.61,30.81 v1(44.92,30.81) ; C48.1 46.92,29.32 U5.K8 v1(47.32,30.01) v1(48.92,30.01) ; v1(44.12,30.01) 43.61,29.5 C46.1 43.61,28.7 v1(43.32,28.41) v1(44.12,27.61)
  BOTTOM w0.381: C44.1 C54.1 v1(39.32,26.81) ; C53.1 34.8,25.15 C39.2 ; C40.2 34.8,28.07 C52.1 ; C40.2 34.8,28.83 C51.1 ; C40.2 35.56,28.07 v1(35.56,27.37) 35.56,26.99 ; C52.1 34.8,25.91 C39.2 ; C52.1 35.56,26.99 ; C39.2 35.56,25.91 v1(35.56,26.61) 35.56,26.99 ; 29.21,13.78 L3.2 28.57,13.78 v1(28.57,13.08) v1(29.21,13.08) 29.21,13.78
VDD_MPU: length 33.6
  TOP w0.254: U5.F10 45.25,26.48 44.59,26.48 U5.F11 U5.F12 v1(43.32,26.01) U5.F13 v1(42.52,26.81) U5.G13 42.81,27.32 42.81,27.9 U5.H13 v1(42.52,28.41) U5.J13
  TOP w0.508: v1(36.08,22.1) v1(36.08,21.46)
  TOP w0.635: 26.29,11.3 30.48,11.3 33.15,13.97 33.15,17.27 34.92,19.05 34.92,21.06 35.56,21.69 36.08,21.69
  BOTTOM w0.305: v1(43.32,26.01) 43.43,25.9 C63.1
  BOTTOM w0.381: C65.1 42.63,28.52 v1(42.52,28.41) ; C62.2 35.31,21.46 v1(36.08,21.46) v1(36.08,22.1) 35.43,22.1 35.18,21.84 C62.2 ; C62.2 34.8,21.21 C64.1 ; v1(27.11,9.91) v1(26.48,9.91) 26.48,8.89 L2.2 27.11,8.89 v1(27.11,9.91)
VDD_MPUON: length 10.6
  TOP w0.121: U5.A2 51.72,20.67 52.32,20.07 52.32,19.3 52.7,18.92 53.34,18.92 54.61,17.65 54.61,16.64 54.99,16.26 55.57,16.26 56.27,15.56 TP2.1
VDD_PHYA: length 18.1
  TOP w0.254: U14.1 23.33,28.03 v1(22.99,27.69) ; U14.27 22,31.87 21.78,32.08 21.78,32.26 21.27,32.77 v1(21.27,33.02)
  BOTTOM w0.381: R121.2 v1(18.73,30.16) ; v1(21.27,33.02) 22.29,33.02 C133.2 ; v1(21.27,35.88) FB4.2 22.61,35.82 C133.2 ; R123.2 v1(18.73,32.07) ; R122.2 v1(18.73,31.11) ; C133.2 22.61,31.37 22.99,30.99 C132.1 C131.1 v1(22.99,27.69) ; R120.2 v1(18.73,29.21) ; R137.2 v1(10.67,29.21)
VDD_PLL: length 15
  TOP w0.254: U5.R10 45.32,33.62 v1(44.92,34.01) U5.R11 v1(44.12,33.21) ; U5.H15 v1(40.92,27.61) ; v1(48.12,25.21) U5.E7
  LYR3 w0.381: v1(44.92,34.01) v1(44.12,33.21) 43.29,32.38 41.66,32.38 41.23,31.96 41.22,31.96 41.14,31.88 40.11,31.88 39.85,31.62 39.85,31.39 39.51,31.05 39.08,31.05 v1(38.52,31.61)
  BOTTOM w0.305: C94.1 v1(44.12,33.21)
  BOTTOM w0.635: FB1.2 36.26,32.07 36.72,31.61 v1(38.52,31.61)
VDD_RTC: length 5.4
  TOP w0.254: v1(48.92,24.41) U5.D6
  BOTTOM w0.121: C104.1 48.75,20.66 48.75,22.29 49.32,22.86 49.32,23.54 49.32,24.01 v1(48.92,24.41)
VDDS: length 56.7
  TOP w0.254: U5.N6 v1(48.12,31.61) ; U5.E14 v1(41.72,25.21) ; v1(46.52,26.01) U5.F9 ; v1(41.72,33.21) U5.P14 ; v1(43.32,30.01) U5.K13 ; v1(46.52,33.21) U5.P9 ; U5.E6 v1(48.92,25.21)
  TOP w0.381: R8.2 R9.1 v1(10.92,19.56)
  LYR5_PWR w0.305: v1(43.32,30.01) 43.81,29.52 45.41,29.52 v1(45.72,29.21)
  BOTTOM w0.121: 39.67,32.81 41.09,32.81 41.17,32.89 41.4,32.89 v1(41.72,33.21) ; 41.32,35.26 41.32,33.61
  BOTTOM w0.254: 41.32,33.61 v1(41.72,33.21) ; 39.67,32.81 39.27,32.41 C84.1
  BOTTOM w0.305: C80.1 41.32,35.91 41.32,35.91 41.32,35.26
  BOTTOM w0.381: v1(10.92,19.56) 11.68,19.56 14.86,22.73 19.68,22.73 21.08,24.13 28.19,24.13 28.57,23.75 32.26,23.75 33.02,22.99 36.32,22.99 37.83,21.48 38.88,21.48 39.24,21.84 39.24,22.73 ; C81.1 46.76,36.3 46.48,36.58 46.48,37.21 46.12,37.57 44.6,37.57 44.07,38.1 42.28,38.1 41.91,37.73 41.91,36.58 41.64,36.3 C80.1
  vias: v1(40.12,26.01)
VDDS_DDR: length 56.4
  TOP w0.254: v1(60.7,25.57) U12.H2 ; v1(59.9,20.76) U12.N1 ; U5.K5 v1(49.72,30.01) U5.L5 ; U5.E5 U5.F5 v1(49.72,26.81) U5.G5 ; v1(61.5,27.97) U12.D2 ; v1(60.7,30.37) U12.B2 ; v1(59.9,19.16) U12.R1 ; v1(67.1,20.76) U12.N9 ; v1(67.1,27.97) U12.E9 ; v1(66.3,23.16) U12.K8 ; v1(67.1,25.57) U12.H9 ; v1(59.9,29.57) U12.C1 ; v1(59.9,31.17) U12.A1 ; v1(60.7,23.16) U12.K2 ; v1(59.9,27.17) U12.F1 ; v1(67.1,29.57) U12.C9 ; v1(66.3,31.17) U12.A8 ; U5.H5 v1(49.72,28.41) U5.J5 ; v1(65.5,26.37) U12.G7 ; v1(67.1,28.77) U12.D9 ; v1(67.1,19.16) U12.R9
  TOP w0.381: C96.2 v1(55.37,15.81) ; 20.13,8.06 C9.2 20.76,8.45 v1(20.76,7.11) v1(20.13,7.11) 20.13,8.06
  BOTTOM w0.305: C100.1 49.72,26.12 v1(49.72,26.81) 49.72,27.5 C99.1 49.72,27.72 v1(49.72,28.41) 49.72,29.1 C98.1 49.72,29.32 v1(49.72,30.01) 49.72,30.7 C97.1
  BOTTOM w0.381: v1(67.1,29.57) C115.1 ; v1(52.83,20.32) v1(52.83,19.56) 53.59,19.56 C95.2 53.59,20.32 v1(52.83,20.32) ; v1(52.83,20.32) 52.2,20.32 C101.1 ; C107.1 v1(59.9,31.17) ; v1(66.3,23.16) 67.5,24.36 C119.1 ; C122.2 v1(66.04,16.83) ; v1(67.1,25.57) C117.1 ; R6.2 18.8,7.49 19.18,7.11 v1(20.13,7.11) v1(20.76,7.11) ; v1(55.37,15.81) 55.24,15.68 C103.1 C102.1 ; R97.1 v1(64.01,18.36) ; v1(67.1,27.97) C116.1 ; v1(59.9,20.76) C112.1 ; v1(67.1,20.76) C120.1 ; C114.1 v1(66.3,31.17) ; R98.1 64.7,25.57 v1(65.5,26.37) ; C109.1 v1(59.9,27.17) ; v1(67.1,19.16) C121.1 ; C111.1 59.49,22.61 60.14,22.61 v1(60.7,23.16) ; v1(60.7,25.57) 60.1,26.16 59.52,26.16 C110.1 ; C113.1 v1(59.9,19.16) ; C118.2 v1(66.04,32.7) ; v1(59.9,29.57) C108.1
  vias: v1(49.91,5.97) v1(50.55,5.97) v1(53.72,5.97) v1(54.36,5.97) v1(57.91,5.97) v1(58.67,5.97) v1(59.44,5.97)
12M_LOOP: length 2.9
  BOTTOM w0.121: U6.3 44.45,11.76 44.58,11.63 44.58,11.23 44.45,11.1 U6.2
12MHZ: length 50.9
  TOP w0.121: U11.27 64.75,34.95 v1(64.9,34.8)
  LYR4 w0.133: v1(64.9,34.8) 65.41,35.31 69.22,35.31 71.37,33.15 71.37,18.16 70.48,17.27 69.41,17.27 66.36,14.22 61.98,14.22 v1(60.2,12.45)
  BOTTOM w0.121: v1(60.2,12.45) 59.56,13.08 49.66,13.08 49.02,12.45 49.02,11.18 48.77,10.92 R21.2
AIN0: length 38.3
  TOP w0.121: U5.B6 48.12,22.81 48.12,22.16 48.51,21.77 48.51,20.45 47.86,19.79 47.86,10.05 48.26,9.65 59.18,9.65 62.61,6.22 65.41,6.22 66.67,4.95 66.67,3.17 P9.39
AIN1: length 31.2
  TOP w0.121: v1(48.12,23.61) U5.C7
  LYR4 w0.133: v1(48.12,23.61) 48.51,23.22 48.51,20.95 51.28,18.19 51.29,18.19 51.56,17.91 51.56,17.53 54.1,14.99 54.1,12.7 60.71,6.1 66.29,6.1 P9.40
AIN2: length 36.8
  TOP w0.121: U5.B7 47.32,22.81 47.32,22.2 48.01,21.51 48.01,20.7 47.36,20.06 47.36,9.53 47.75,9.14 58.67,9.14 62.1,5.71 63.63,5.71 64.26,5.08 64.26,3.05 P9.37
AIN3: length 33.1
  TOP w0.121: P9.38 63.88,5.97 62.36,5.97 58.93,9.4 48.01,9.4 47.61,9.79 47.61,19.93 48.27,20.58 48.27,21.63 47.72,22.18 U5.A7
AIN4: length 28.7
  TOP w0.121: U5.C8 v1(47.32,23.61)
  LYR4 w0.133: P9.33 61.59,3.17 61.59,4.7 53.72,12.57 53.72,14.52 50.67,17.56 50.67,18.29 48.13,20.83 48.13,22.8 v1(47.32,23.61)
AIN5: length 32.4
  TOP w0.121: P9.36 62.43,4.45 58.24,8.64 47.24,8.64 46.86,9.02 46.86,21.84 46.52,22.19 46.52,22.81 U5.B8
AIN6: length 35.8
  TOP w0.121: P9.35 63.88,2.92 63.88,4.95 63.37,5.46 61.85,5.46 58.42,8.89 47.5,8.89 47.12,9.27 47.12,20.19 47.75,20.83 47.75,21.34 46.92,22.17 U5.A8
AIN7: length 10.4
  TOP w0.121: U5.C9 v1(46.52,23.61)
  LYR4 w0.133: v1(48.26,17.78) 47.75,18.29 47.75,22.38 v1(46.52,23.61)
  BOTTOM w0.121: R164.1 48.77,15.68 48.58,15.88 48.58,16.51 48.39,16.7 R163.2 47.94,17.46 v1(48.26,17.78)
B_UART0_RX: length 13.6
  TOP w0.121: J1.4 49.02,6.48 47.12,6.48 46.35,7.24 R165.1
  BOTTOM w0.121: J1.4 52.2,9.65 52.2,10.92 51.94,11.18 U15.2
B_UART0_TX: length 5.2
  BOTTOM w0.121: J1.5 52.7,8.64 52.45,8.89 52.45,11.18 51.95,11.68 U15.3
CAP_VBB_MPU: length 4.2
  TOP w0.121: U5.C10 44.93,23.62 v1(44.92,23.61)
  BOTTOM w0.121: C91.1 45.4,22.42 44.92,22.9 v1(44.92,23.61)
CAP_VDD_SRAM_CORE: length 5.2
  TOP w0.121: U5.D9 v1(46.52,24.41)
  BOTTOM w0.121: C89.1 46.35,22.48 46.92,23.04 46.92,24.01 v1(46.52,24.41)
CAP_VDD_SRAM_MPU: length 5
  TOP w0.121: v1(44.12,24.41) U5.D11
  BOTTOM w0.121: C90.1 44.52,20.26 44.52,24.01 v1(44.12,24.41)
CLKOUT2: length 57.6
  BOTTOM w0.121: P2.18 36,17.46 35.67,17.8 35.67,19.98 36.26,20.57 39.88,20.57 40.13,20.83 40.89,20.83 41.08,20.64 41.08,19.68 R19.2 R20.1 42.55,18.54 41.59,17.59 41.59,14.29 42.23,13.65 46.7,13.65 46.89,13.84 60.71,13.84 61.72,12.83 61.72,9.91 65.15,6.48 69.98,6.48 71.63,4.83 71.63,3.05 P9.41
CLKOUT_SRC: length 5.1
  TOP w0.121: U5.D14 v1(41.72,24.41)
  BOTTOM w0.121: v1(41.72,24.41) 41.32,24.01 41.32,23.26 41.59,22.99 R19.1
CRS: length 2.8
  TOP w0.121: R139.2 29.51,32.24 28.92,32.24 v1(28.45,31.76) 28.35,31.87 U14.14
DDR_A0: length 23.9
  TOP w0.121: v1(61.5,20.76) U12.N3 ; U5.F3 v1(51.32,26.01)
  LYR3 w0.133: v1(53.85,23.11) 53.34,23.11 53.21,22.99 53.21,21.21 54.86,19.56 54.86,19.3 57.02,17.14 61.59,17.14 62.36,17.91 62.36,20.7 61.98,21.08 61.82,21.08 v1(61.5,20.76)
  BOTTOM w0.121: v1(51.32,26.01) 51.73,26.42 52.32,26.42 52.58,26.16 52.58,24.38 v1(53.85,23.11)
DDR_A1: length 24.1
  TOP w0.121: U5.H1 54.54,28.01 56.58,25.97 57.72,25.97 58.93,24.77 v1(58.93,23.88) ; v1(65.5,19.96) U12.P7
  LYR3 w0.121: 60.2,23.87 60.5,23.57 61.67,23.57
  LYR3 w0.133: 61.67,23.57 61.78,23.57 62.23,23.11 62.61,23.11 63.88,21.84 63.88,20.83 63.5,20.45 63.5,18.9 63.63,18.77 64.39,18.77 64.52,18.9 64.52,19.05 64.39,19.18 64.01,19.18 63.88,19.3 63.88,20.19 64.01,20.32 64.14,20.32 64.26,20.19 64.26,19.68 64.39,19.56 64.64,19.56 64.77,19.68 64.77,20.19 64.9,20.32 65.14,20.32 v1(65.5,19.96) ; 60.2,23.87 58.93,23.87 v1(58.93,23.88)
DDR_A2: length 23.9
  TOP w0.121: v1(61.5,19.96) U12.P3 ; U5.E4 v1(50.52,25.21)
  LYR3 w0.121: v1(61.5,19.96) 61.1,20.36 61.1,22.09
  LYR3 w0.133: v1(50.52,25.21) 50.52,24.98 51.12,24.38 54.36,24.38 55.12,25.15 55.12,26.04 54.26,26.9 54.26,27.08 54.5,27.32 54.72,27.32 56.64,25.4 56.64,24.38 56.77,24.26 57.4,24.26 57.51,24.16 57.51,23.72 57.4,23.62 56.77,23.62 56.64,23.5 56.64,22.1 56.77,21.97 59.05,21.97 59.44,22.35 60.83,22.35 61.1,22.09
DDR_A3: length 24
  TOP w0.121: v1(60.7,20.76) U12.N2 ; v1(51.32,23.61) U5.C3
  LYR3 w0.121: 59.61,21.16 60.3,21.16 v1(60.7,20.76)
  LYR3 w0.133: 59.61,21.16 59.56,21.21 56.01,21.21 55.88,21.34 55.88,24.43 55.8,24.51 55.58,24.51 55.5,24.43 55.5,22.2 55.42,22.12 55.07,22.12 54.99,22.05 54.99,21.67 54.91,21.59 54.69,21.59 54.61,21.67 54.61,22.05 54.53,22.12 54.37,22.12 54.29,22.2 54.29,22.4 54.37,22.48 55.04,22.48 55.12,22.56 55.12,22.78 55.04,22.86 54.37,22.86 54.29,22.94 54.29,23.16 54.37,23.24 55.04,23.24 55.12,23.32 55.12,23.53 55.04,23.61 52.96,23.61 52.83,23.48 52.83,22.35 52.7,22.23 52.45,22.23 52.32,22.35 52.32,23.48 52.2,23.61 v1(51.32,23.61)
DDR_A4: length 23.9
  TOP w0.121: U5.C2 52.12,23.61 52.12,23.05 52.36,22.81 52.68,22.81 52.96,22.53 52.96,21.34 53.72,20.57 53.72,19.81 56.52,17.02 56.52,16.64 v1(56.13,16.26) ; v1(66.3,19.96) U12.P8
  LYR3 w0.121: v1(66.3,19.96) 65.9,19.56 65.28,19.56
  LYR3 w0.133: 65.28,19.56 65.02,19.3 65.02,17.02 64.77,16.76 63.12,16.76 62.36,16 56.39,16 v1(56.13,16.26)
DDR_A5: length 23.9
  TOP w0.121: v1(53.85,22.1) 53.47,22.1 53.34,22.23 53.34,22.61 52.74,23.21 U5.B1 ; v1(60.7,19.96) U12.P2
  LYR3 w0.121: 61.09,18.16 61.1,18.17 61.1,19.56 v1(60.7,19.96)
  LYR3 w0.133: 61.09,18.16 60.83,17.91 59.44,17.91 59.31,18.03 59.31,20.7 59.18,20.83 57.78,20.83 57.66,20.7 57.66,18.41 57.53,18.29 56.9,18.29 56.64,18.54 56.64,20.7 56.52,20.83 56.26,20.83 56.13,20.7 56.13,19.68 56.01,19.56 55.75,19.56 55.63,19.68 55.63,21.64 55.55,21.72 55.32,21.72 55.24,21.64 55.24,21.03 55.17,20.95 54.54,20.95 54.29,21.2 54.29,21.65 v1(53.85,22.1)
DDR_A6: length 24.1
  TOP w0.121: v1(49.72,24.41) U5.D5 ; v1(66.3,19.16) U12.R8
  BOTTOM w0.121: v1(66.3,19.16) 65.9,18.76 65.9,18.15 64.52,16.76 57.28,16.76 55.37,18.67 55.37,21.21 53.98,22.61 53.59,22.61 51.39,24.81 50.12,24.81 v1(49.72,24.41)
DDR_A7: length 24.1
  TOP w0.121: v1(57.15,19.91) 57.63,19.43 58.17,19.43 58.29,19.3 58.29,18.03 58.17,17.91 57.4,17.91 55.63,19.68 55.63,23.88 54.36,25.15 54.36,25.78 54.13,26.01 52.12,26.01 U5.E2 ; v1(60.7,19.16) U12.R2
  BOTTOM w0.121: v1(57.15,19.91) 59.16,19.91 59.61,20.36 62.23,20.36 62.36,20.24 62.36,19.69 62.23,19.56 U12.R2 v1(60.7,19.16)
DDR_A8: length 23.9
  TOP w0.121: v1(50.52,24.41) U5.D4 ; v1(66.3,18.36) U12.T8
  BOTTOM w0.121: v1(66.3,18.36) 66.3,18.04 64.64,16.38 57.15,16.38 54.99,18.54 54.99,20.68 54.61,21.06 52.19,21.06 51.94,21.31 51.94,23.75 51.28,24.41 v1(50.52,24.41)
DDR_A9: length 24
  TOP w0.121: v1(53.85,21.46) 53.85,20.95 53.97,20.83 54.13,20.83 54.25,20.95 54.25,22.46 54.1,22.61 53.79,22.61 53.09,23.31 53.09,23.44 U5.C1 ; v1(61.5,19.16) U12.R3
  LYR3 w0.133: v1(53.85,21.46) 53.85,21.08 54.36,20.57 54.99,20.57 55.24,20.32 55.24,19.43 57.15,17.53 58.04,17.53 58.17,17.65 58.17,20.32 58.29,20.45 58.67,20.45 58.8,20.32 58.8,17.65 58.93,17.53 61.47,17.53 61.98,18.03 61.98,19.43 61.85,19.56 61.63,19.56 61.5,19.43 v1(61.5,19.16)
DDR_A10: length 24
  TOP w0.121: U5.F4 v1(50.52,26.01) ; v1(65.5,22.36) U12.L7
  LYR3 w0.121: 51.68,26.41 50.92,26.41 v1(50.52,26.01)
  LYR3 w0.133: v1(65.5,22.36) 65.79,22.65 65.79,22.86 65.66,22.99 64.77,22.99 64.64,23.11 64.64,23.37 64.77,23.5 65.66,23.5 65.79,23.62 65.79,23.88 65.66,24 64.39,24 62.36,26.04 59.31,26.04 57.72,27.62 56.83,27.62 55.75,28.71 52.58,28.71 52.2,28.32 52.2,26.92 51.68,26.41
DDR_A11: length 23.9
  TOP w0.121: v1(65.5,19.16) U12.R7 ; v1(53.85,26.81) 52.12,26.81 U5.F2
  BOTTOM w0.121: v1(53.85,26.81) 53.34,26.3 53.34,24.77 54.61,23.5 55.88,23.5 56.13,23.24 56.13,18.92 57.53,17.53 64.14,17.53 64.77,18.16 64.77,18.91 65.02,19.16 v1(65.5,19.16)
DDR_A12: length 24.1
  TOP w0.121: v1(65.5,20.76) U12.N7 ; v1(51.32,25.21) U5.E3
  LYR3 w0.133: v1(51.32,25.21) 51.38,25.15 54.1,25.15 54.36,25.4 54.36,25.78 54.1,26.04 53.21,26.04 52.96,26.29 52.96,27.69 53.21,27.94 55.12,27.94 56.64,26.42 57.91,26.42 59.56,24.77 61.22,24.77 61.47,25.02 62.23,25.02 63.88,23.37 63.88,22.38 v1(65.5,20.76)
DDR_A13: length 24
  TOP w0.121: v1(61.5,18.36) U12.T3 ; U5.H3 v1(51.32,27.61)
  BOTTOM w0.121: v1(61.5,18.36) 63.37,18.36 63.5,18.24 63.5,18.03 63.37,17.91 57.66,17.91 56.52,19.05 56.52,23.62 56.26,23.88 54.74,23.88 54.36,24.26 54.36,27.18 53.92,27.61 v1(51.32,27.61)
DDR_A14: length 24
  TOP w0.121: v1(65.5,18.36) U12.T7 ; v1(50.52,27.61) U5.H4
  BOTTOM w0.121: v1(50.52,27.61) 50.52,27.58 50.9,27.21 52.55,27.21 52.96,26.8 52.96,24.64 55.75,21.84 55.75,18.8 57.4,17.14 64.28,17.14 v1(65.5,18.36)
DDR_A15: length 24.1
  TOP w0.121: U5.D3 51.32,24.41 53.57,24.41 54.61,23.37 54.61,19.43 57.15,16.89 63.88,16.89 64.52,17.53 64.52,21.38 U12.M7
DDR_BA0: length 24.1
  TOP w0.121: v1(60.7,21.56) U12.M2 ; U5.C4 v1(50.52,23.61)
  LYR3 w0.121: 50.92,23.74 50.92,22.48 ; 50.12,22.48 50.12,23.48 50.25,23.61 v1(50.52,23.61)
  LYR3 w0.133: 50.92,23.74 50.92,23.89 51.05,24.02 54.5,24.02 55.5,25.02 55.5,25.65 55.6,25.75 55.78,25.75 56.26,25.27 56.26,21.97 56.64,21.59 59.18,21.59 59.56,21.97 60.57,21.97 60.7,21.84 v1(60.7,21.56) ; 50.12,22.48 50.12,21.46 50.25,21.34 50.42,21.34 50.55,21.46 50.55,21.84 50.67,21.97 50.93,21.97 51.05,21.84 51.05,21.46 51.18,21.34 51.44,21.34 51.56,21.46 51.56,22.23 51.44,22.35 51.05,22.35 50.92,22.48
DDR_BA1: length 24.1
  TOP w0.121: v1(66.3,20.76) U12.N8 ; U5.E1 v1(53.85,25.61)
  LYR3 w0.133: v1(66.3,20.76) 65.82,21.24 65.82,21.65 65.66,21.82 65.05,21.82 64.23,22.63 64.23,23.52 62.1,25.65 61.34,25.65 61.21,25.53 61.21,25.27 61.09,25.15 59.69,25.15 58.08,26.76 56.93,26.76 55.37,28.32 52.83,28.32 52.58,28.07 52.58,26.54 52.32,26.29 52.32,25.91 52.62,25.61 v1(53.85,25.61)
DDR_BA2: length 24.1
  TOP w0.121: v1(51.32,22.81) U5.B3 ; v1(61.5,21.56) U12.M3
  LYR3 w0.133: v1(61.5,21.56) 61.98,21.56 62.1,21.69 62.1,22.1 62.23,22.23 62.48,22.23 62.74,21.97 62.74,21.59 62.48,21.34 62.48,21.08 62.74,20.83 62.74,17.53 61.98,16.76 56.9,16.76 54.48,19.18 54.48,19.43 52.7,21.21 52.51,21.21 52.39,21.08 52.39,20.83 52.26,20.7 52.07,20.7 51.94,20.83 51.94,22.99 51.82,23.11 51.63,23.11 v1(51.32,22.81)
DDR_CASN: length 24
  TOP w0.121: U5.F1 54.48,26.41 54.74,26.16 54.74,25.4 55.37,24.77 55.88,24.77 56.01,24.64 56.01,19.81 56.13,19.68 56.52,19.68 56.64,19.81 56.64,21.21 56.77,21.34 57.42,21.34 57.55,21.21 57.55,19.94 57.68,19.81 58.17,19.81 58.29,19.94 58.29,20.19 58.17,20.32 58.04,20.32 57.91,20.45 57.91,20.7 58.04,20.83 58.17,20.83 58.29,20.95 58.29,21.46 58.17,21.59 57.28,21.59 57.15,21.72 v1(57.15,22.48) ; v1(61.5,23.16) U12.K3
  LYR3 w0.133: v1(61.5,23.16) 61.07,22.73 59.31,22.73 59.05,22.48 v1(57.15,22.48)
DDR_CKE: length 25.1
  TOP w0.121: U5.G3 v1(51.32,26.81) ; v1(67.1,23.16) U12.K9
  LYR3 w0.133: v1(67.1,23.16) 67.31,23.37 67.31,24.26 67.18,24.38 64.64,24.38 62.61,26.42 59.44,26.42 57.91,27.94 57.02,27.94 55.88,29.08 53.21,29.08 52.83,29.46 51.18,29.46 51.05,29.34 51.05,29.08 51.18,28.96 51.69,28.96 51.82,28.83 51.82,27.3 v1(51.32,26.81)
  BOTTOM w0.121: R96.2 v1(67.1,23.16)
DDR_CLK: length 24
  TOP w0.095: U12.J7 64.94,24.2 64.74,24.2 63.75,23.22 63.75,19.7 61.58,17.53 57.42,17.53 55.27,19.67 55.27,23.72 53.8,25.2 52.36,25.2 51.98,24.81 U5.D2
DDR_CLKN: length 24
  TOP w0.095: U12.K7 65.37,23.56 65.48,23.67 65.48,23.82 65.37,23.92 64.85,23.92 64.03,23.1 64.03,19.58 61.7,17.25 57.3,17.25 54.99,19.56 54.99,23.61 53.68,24.92 52.63,24.92 U5.D1
DDR_CSN: length 23.9
  TOP w0.121: U5.H2 52.12,28.41 54.65,28.41 56.71,26.35 57.85,26.35 59.44,24.77 59.44,23.44 59.36,23.37 58.88,23.37 58.8,23.29 58.8,22.09 59.05,21.84 59.05,18.41 59.18,18.29 59.31,18.29 59.44,18.41 59.44,21.97 59.18,22.23 59.18,22.78 59.26,22.86 59.49,22.86 59.56,22.78 59.56,22.44 59.64,22.36 60.7,22.36 U12.L2
DDR_D0: length 23.3
  TOP w0.121: v1(62.3,27.97) U12.E3 ; v1(51.32,31.61) U5.M3
  LYR3 w0.133: v1(51.32,31.61) 51.68,31.61 52.96,32.89 60.45,32.89 63.75,29.59 63.75,27.43 63.63,27.3 63.12,27.3 62.99,27.43 62.99,29.72 62.87,29.84 62.43,29.84 62.3,29.72 v1(62.3,27.97)
DDR_D1: length 23.3
  TOP w0.121: v1(50.52,31.61) U5.M4 ; v1(65.5,27.17) U12.F7
  LYR3 w0.121: v1(50.52,31.61) 50.92,31.21 50.92,30.64 51.16,30.41 52.78,30.41 ; v1(65.5,27.17) 65.9,26.77 66.47,26.77 66.7,26.53 66.7,25.74 66.7,25.39 66.47,25.16
  LYR3 w0.133: 66.47,25.16 66.08,24.77 64.89,24.77 62.9,26.76 59.6,26.76 57.4,28.96 56.77,28.96 56.26,29.46 53.72,29.46 52.78,30.41
DDR_D2: length 23.3
  TOP w0.121: U5.N1 55.49,32.01 55.88,31.62 57.02,31.62 57.15,31.75 57.15,32.64 57.02,32.77 54.86,32.77 54.74,32.89 54.74,33.15 54.86,33.27 61.09,33.27 61.21,33.15 61.21,32.13 62.73,30.61 62.73,27.43 62.47,27.17 61.98,27.17 61.98,27.17 61.5,27.17 U12.F2
DDR_D3: length 23.3
  TOP w0.121: v1(66.3,27.17) U12.F8 ; v1(56.13,32.13) 55.86,32.41 52.12,32.41 U5.N2
  BOTTOM w0.121: v1(66.3,27.17) 66.7,27.57 66.7,28.17 66.5,28.37 65.91,28.37 65.58,28.7 64.77,28.7 64.64,28.57 64.64,27.69 64.52,27.56 64.26,27.56 64.14,27.69 64.14,28.57 64.01,28.7 63.75,28.7 63.63,28.57 63.63,27.69 63.5,27.56 63.31,27.56 63.18,27.69 63.18,28.26 62.36,29.08 62.36,30.61 60.83,32.13 v1(56.13,32.13)
DDR_D4: length 23.3
  TOP w0.121: U12.H3 63.52,25.17 64.26,25.91 64.26,31.75 63.37,32.64 v1(62.36,32.64) ; U5.N3 v1(51.32,32.41)
  LYR3 w0.133: v1(51.32,32.41) 51.33,32.41 52.58,33.66 61.34,33.66 v1(62.36,32.64)
DDR_D5: length 23.3
  TOP w0.121: U5.N4 v1(50.52,32.41) ; v1(66.3,25.57) U12.H8
  LYR3 w0.121: v1(50.52,32.41) 50.92,32.01 51.57,32.01
  LYR3 w0.133: v1(66.3,25.57) 65.88,25.15 65.15,25.15 64.26,26.04 64.26,29.72 60.71,33.27 52.83,33.27 51.57,32.01
DDR_D6: length 23.3
  TOP w0.121: U12.G2 61.5,25.56 63.41,25.56 63.88,26.04 63.88,31.24 v1(62.99,32.13) ; U5.P3 v1(51.32,33.21)
  LYR3 w0.133: v1(51.32,33.21) 51.63,33.21 52.45,34.04 61.59,34.04 62.99,32.64 v1(62.99,32.13)
DDR_D7: length 23.3
  TOP w0.121: U5.P4 v1(50.52,33.21) ; v1(65.5,25.57) U12.H7
  LYR3 w0.121: 51.52,33.61 50.92,33.61 v1(50.52,33.21)
  LYR3 w0.133: v1(65.5,25.57) 64.77,26.3 64.77,31.5 61.87,34.39 52.3,34.39 51.52,33.61
DDR_D8: length 20.3
  TOP w0.121: U5.J1 54.76,28.81 56.83,26.73 58.86,26.73 59.37,26.23 59.37,25.34 59.94,24.77 62.23,24.77 62.36,24.64 62.36,23.24 62.48,23.11 62.99,23.11 64.64,24.77 64.64,27.91 U12.D7
DDR_D9: length 20.3
  TOP w0.121: U5.K1 55.77,29.61 v1(56.13,29.97) ; v1(61.5,29.57) U12.C3
  LYR3 w0.133: v1(56.13,29.97) 56.52,29.97 56.64,30.1 56.64,32 56.77,32.13 57.53,32.13 57.66,32 57.66,29.84 57.78,29.72 58.29,29.72 58.42,29.84 58.42,32 58.55,32.13 59.05,32.13 59.18,32 59.18,28.83 59.31,28.7 61.37,28.7 61.5,28.83 v1(61.5,29.57)
